# Keil uVision project flashloader_cm7.uvprojx, settings and files
target flashloader_cm7 release (ARM-ADS)
  device: MIMXRT1176DVMAB:cm7 NXP
  pack: NXP.MIMXRT1176_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: flashloader_cm7.out
  AfterMake: fromelf.exe --output "$Lflashloader.bin" --bincombined "#L"
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CPU_MIMXRT1176DVMAB_cm7, CPU_IS_ARM_CORTEX_M7=1, XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, BL_TARGET_RAM, MIMXRT1176, USB_STACK_BM, PINT_USE_SIMPLE_CALLBACK=1, SDK_DEBUGCONSOLE=1, MIMXRT1176_cm7_SERIES, OSA_USED, DEBUG, USE_RTOS=0
  c misc: -include ../mcux_config.h -include ../mcuxsdk_version.h -fno-common  -fdata-sections  -fno-builtin  -mthumb  -ffreestanding  -Wno-null-dereference  -Wno-unknown-attributes  -Wno-expansion-to-defined  -Wparentheses-equality  -Wno-invalid-noreturn
  c include: ..;../../../../xip;../../../../../../devices/MIMXRT1176/drivers;../../../../../../CMSIS/Core/Include;../../../../../../CMSIS/Core/Include/m-profile;../../../../../../devices/MIMXRT1176;../../../../../../devices/MIMXRT1176/periph;../../../../../../devices/MIMXRT1176/drivers/cm7;../../../../../../devices/MIMXRT1176/utilities/debug_console_lite;../../../../../../components/lists;../../../../../../devices/MIMXRT1176/utilities/str;../../../../../../components/uart;../../../../../../components/osa;../../../../../../middleware/usb/include;../../../../../../middleware/usb/phy;../../../../../../middleware/mcu_bootloader/src/autobaud;../../../../../../middleware/mcu_bootloader/src/bootloader;../../../../../../middleware/mcu_bootloader/src/crc;../../../../../../middleware/mcu_bootloader/src/include;../../../../../../middleware/mcu_bootloader/src/memory;../../../../../../middleware/mcu_bootloader/src/memory/src;../../../../../../middleware/mcu_bootloader/src/packet;../../../../../../middleware/mcu_bootloader/src/property;../../../../../../middleware/mcu_bootloader/src/sbloader;../../../../../../middleware/mcu_bootloader/src/utilities;../../../../../../middleware/mcu_bootloader/src/startup;../../../../../../middleware/usb/device;../../../../../../middleware/usb/device/class;../../../../../../middleware/mcu_bootloader/src/bm_usb;../../../../../../middleware/mcu_bootloader/src/drivers/ocotp;../../../../../../middleware/mcu_bootloader/src/drivers/serial_nor_eeprom;../../../../../../middleware/mcu_bootloader/src/drivers/usdhc;../../../../../../middleware/mcu_bootloader/src/drivers/sdmmc/inc;../../../../../../middleware/mcu_bootloader/src/drivers/semc;../../../../../../middleware/mcu_bootloader/src/drivers/semc_nand;../../../../../../middleware/mcu_bootloader/src/drivers/nand_ecc;../../../../../../middleware/mcu_bootloader/src/drivers/flexspi;../../../../../../middleware/mcu_bootloader/src/drivers/flexspi_nor;../../../../../../middleware/mcu_bootloader/src/drivers/flexspi_nand;../../../../../../middleware/mcu_bootloader/src/drivers/microseconds;../../../../../../devices/MIMXRT1052;../../../../../../middleware/mcu_bootloader/targets/MIMXRT1176/src;../../../../../../middleware/mcu_bootloader/src;../../../../../../middleware/mcu_bootloader/src/authentication;../../../../../../middleware/mcu_bootloader/src/security/keyblob;../../../../../../middleware/mcu_bootloader/src/drivers
  asm define: BL_HAS_BOOTLOADER_CONFIG=0, NDEBUG, CPU_MIMXRT1176DVMAB_cm7, MIMXRT1176_cm7_SERIES, OSA_USED, DEBUG
  asm misc: -include ../mcux_config.h
  asm include: ..;../../../../xip;../../../../../../devices/MIMXRT1176/drivers;../../../../../../CMSIS/Core/Include;../../../../../../CMSIS/Core/Include/m-profile;../../../../../../devices/MIMXRT1176;../../../../../../devices/MIMXRT1176/periph;../../../../../../devices/MIMXRT1176/drivers/cm7;../../../../../../devices/MIMXRT1176/utilities/debug_console_lite;../../../../../../components/lists;../../../../../../devices/MIMXRT1176/utilities/str;../../../../../../components/uart;../../../../../../components/osa;../../../../../../middleware/usb/include;../../../../../../middleware/usb/phy;../../../../../../middleware/mcu_bootloader/src/startup;../../../../../../middleware/mcu_bootloader/src/autobaud;../../../../../../middleware/mcu_bootloader/src/bootloader;../../../../../../middleware/mcu_bootloader/src/crc;../../../../../../middleware/mcu_bootloader/src/include;../../../../../../middleware/mcu_bootloader/src/memory;../../../../../../middleware/mcu_bootloader/src/memory/src;../../../../../../middleware/mcu_bootloader/src/packet;../../../../../../middleware/mcu_bootloader/src/property;../../../../../../middleware/mcu_bootloader/src/sbloader;../../../../../../middleware/mcu_bootloader/src/utilities;../../../../../../middleware/usb/device;../../../../../../middleware/usb/device/class;../../../../../../middleware/mcu_bootloader/src/bm_usb;../../../../../../middleware/mcu_bootloader/src/drivers/ocotp;../../../../../../middleware/mcu_bootloader/src/drivers/serial_nor_eeprom;../../../../../../middleware/mcu_bootloader/src/drivers/usdhc;../../../../../../middleware/mcu_bootloader/src/drivers/sdmmc/inc;../../../../../../middleware/mcu_bootloader/src/drivers/semc;../../../../../../middleware/mcu_bootloader/src/drivers/semc_nand;../../../../../../middleware/mcu_bootloader/src/drivers/nand_ecc;../../../../../../middleware/mcu_bootloader/src/drivers/flexspi;../../../../../../middleware/mcu_bootloader/src/drivers/flexspi_nor;../../../../../../middleware/mcu_bootloader/src/drivers/flexspi_nand;../../../../../../middleware/mcu_bootloader/src/drivers/microseconds;../../../../../../devices/MIMXRT1052;../../../../../../middleware/mcu_bootloader/targets/MIMXRT1176/src;../../../../../../middleware/mcu_bootloader/src;../../../../../../middleware/mcu_bootloader/src/authentication;../../../../../../middleware/mcu_bootloader/src/security/keyblob;../../../../../../middleware/mcu_bootloader/src/drivers
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1176_ram_flashloader.scf
  link misc: --remove --entry=Reset_Handler --info=sizes,totals,unused,veneers
  group source
    ../: pin_mux.c pin_mux.h fsl_os_abstraction_config.h mcux_config.h mcux_config.h mcux_config.h mcuxsdk_version.h
  group board
    ../: clock_config.h clock_config.c
  group xip
    ../../../../xip/: evkbmimxrt1170_flexspi_nor_config.c evkbmimxrt1170_flexspi_nor_config.h
    ../../../../: dcd.c dcd.h xmcd.c xmcd.h
  group drivers
    ../../../../../../devices/MIMXRT1176/drivers/: fsl_clock.h fsl_clock.c fsl_iomuxc.h fsl_anatop_ai.c fsl_anatop_ai.h fsl_memory.h fsl_dcdc.c fsl_dcdc.h fsl_gpc.c fsl_gpc.h fsl_pgmc.h fsl_pgmc.c fsl_pmu.h fsl_pmu.c fsl_soc_src.c fsl_soc_src.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_gpio.h fsl_gpio.c fsl_lpspi.c fsl_lpspi.h fsl_lpuart.h fsl_lpuart.c fsl_mu.h fsl_mu.c fsl_puf.h fsl_puf.c
    ../../../../../../devices/MIMXRT1176/drivers/cm7/: fsl_cache.c fsl_cache.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_compiler.h cmsis_version.h core_cm7.h
  group CMSIS/m-profile
    ../../../../../../CMSIS/Core/Include/m-profile/: cmsis_armclang_m.h armv7m_cachel1.h armv7m_mpu.h
  group device
    ../../../../../../devices/MIMXRT1176/: fsl_device_registers.h MIMXRT1176_cm7.h MIMXRT1176_cm7_COMMON.h MIMXRT1176_cm7_features.h
  group device/periph
    ../../../../../../devices/MIMXRT1176/periph/: PERI_ADC.h PERI_ADC_ETC.h PERI_ANADIG_LDO_SNVS.h PERI_ANADIG_LDO_SNVS_DIG.h PERI_ANADIG_MISC.h PERI_ANADIG_OSC.h PERI_ANADIG_PLL.h PERI_ANADIG_PMU.h PERI_ANADIG_TEMPSENSOR.h PERI_AOI.h PERI_ASRC.h PERI_AUDIO_PLL.h PERI_CAAM.h PERI_CAN.h PERI_CAN_WRAPPER.h PERI_CCM.h PERI_CCM_OBS.h PERI_CDOG.h PERI_CMP.h PERI_CSI.h PERI_DAC.h PERI_DCDC.h PERI_DCIC.h PERI_DMA.h PERI_DMAMUX.h PERI_DSI_HOST.h PERI_DSI_HOST_APB_PKT_IF.h PERI_DSI_HOST_DPI_INTFC.h PERI_DSI_HOST_NXP_FDSOI28_DPHY_INTFC.h PERI_EMVSIM.h PERI_ENC.h PERI_ENET.h PERI_ENET_QOS.h PERI_ETHERNET_PLL.h PERI_EWM.h PERI_FLEXIO.h PERI_FLEXRAM.h PERI_FLEXSPI.h PERI_GPC_CPU_MODE_CTRL.h PERI_GPC_SET_POINT_CTRL.h PERI_GPC_STBY_CTRL.h PERI_GPIO.h PERI_GPT.h PERI_I2S.h PERI_IEE.h PERI_IEE_APC.h PERI_IOMUXC.h PERI_IOMUXC_GPR.h PERI_IOMUXC_LPSR.h PERI_IOMUXC_LPSR_GPR.h PERI_IOMUXC_SNVS.h PERI_IOMUXC_SNVS_GPR.h PERI_IPS_DOMAIN.h PERI_KEY_MANAGER.h PERI_KPP.h PERI_LCDIF.h PERI_LCDIFV2.h PERI_LMEM.h PERI_LPI2C.h PERI_LPSPI.h PERI_LPUART.h PERI_MCM.h PERI_MECC.h PERI_MIPI_CSI2RX.h PERI_MMCAU.h PERI_MU.h PERI_OCOTP.h PERI_OSC_RC_400M.h PERI_OTFAD.h PERI_PDM.h PERI_PGMC_BPC.h PERI_PGMC_CPC.h PERI_PGMC_MIF.h PERI_PGMC_PPC.h PERI_PHY_LDO.h PERI_PIT.h PERI_PUF.h PERI_PWM.h PERI_PXP.h PERI_RDC.h PERI_RDC_SEMAPHORE.h PERI_RTWDOG.h PERI_SEMA4.h PERI_SEMC.h PERI_SNVS.h PERI_SPDIF.h PERI_SRAM.h PERI_SRC.h PERI_SSARC_HP.h PERI_SSARC_LP.h PERI_TMPSNS.h PERI_TMR.h PERI_USB.h PERI_USBHSDCD.h PERI_USBNC.h PERI_USBPHY.h PERI_USDHC.h PERI_VIDEO_MUX.h PERI_VIDEO_PLL.h PERI_VMBANDGAP.h PERI_WDOG.h PERI_XBARA.h PERI_XBARB.h PERI_XECC.h PERI_XRDC2.h
  group utilities
    ../../../../../../devices/MIMXRT1176/utilities/debug_console_lite/: fsl_assert.h fsl_assert.c
    ../../../../../../devices/MIMXRT1176/utilities/: fsl_memcpy.S
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group utilities/str
    ../../../../../../devices/MIMXRT1176/utilities/str/: fsl_str.h fsl_str.c
  group utilities/debug_console_lite
    ../../../../../../devices/MIMXRT1176/utilities/debug_console_lite/: fsl_debug_console.h fsl_debug_console.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/osa
    ../../../../../../components/osa/: fsl_os_abstraction_bm.h fsl_os_abstraction_bm.c fsl_os_abstraction.h
  group usb/include
    ../../../../../../middleware/usb/include/: usb.h usb_misc.h usb_spec.h
  group usb/phy
    ../../../../../../middleware/usb/phy/: usb_phy.c usb_phy.h usb_phy.c usb_phy.h
  group source/src/autobaud
    ../../../../../../middleware/mcu_bootloader/src/autobaud/: autobaud.h
  group source/src/autobaud/src
    ../../../../../../middleware/mcu_bootloader/src/autobaud/src/: autobaud_irq.c
  group source/src/bootloader
    ../../../../../../middleware/mcu_bootloader/src/bootloader/: bl_peripheral_interface.h bl_user_entry.h bl_version.h bootloader.h bl_command.h bl_context.h bl_peripheral.h bl_shutdown_cleanup.h bl_irq_common.h bl_app_crc_check.h bl_keyblob.h
  group source/src/bootloader/src
    ../../../../../../middleware/mcu_bootloader/src/bootloader/src/: bl_user_entry.c bl_main.c bl_context.c bl_exception_handler.c bl_tree_root.c bl_command.c bl_shutdown_cleanup.c bl_app_crc_check.c bl_misc.c lpuart_peripheral_interface.c usb_hid_msc_peripheral_interface.c
  group source/src/crc
    ../../../../../../middleware/mcu_bootloader/src/crc/: crc16.h crc32.h
  group source/src/crc/src
    ../../../../../../middleware/mcu_bootloader/src/crc/src/: crc16.c crc32.c
  group source/src/include
    ../../../../../../middleware/mcu_bootloader/src/include/: bootloader_common.h bootloader_core.h
  group source/src/memory
    ../../../../../../middleware/mcu_bootloader/src/memory/: memory.h
  group source/src/memory/src
    ../../../../../../middleware/mcu_bootloader/src/memory/src/: sram_init.h memory.c normal_memory.h normal_memory.c pattern_fill.h pattern_fill_mdk.s spi_nor_eeprom_memory.c spi_nor_eeprom_memory.h sd_memory.c sd_memory.h mmc_memory.c mmc_memory.h flexspi_nor_memory.c flexspi_nor_memory.h spinand_memory.c spinand_memory.h semc_nand_memory.c semc_nand_memory.h
  group source/src/packet
    ../../../../../../middleware/mcu_bootloader/src/packet/: command_packet.h serial_packet.h
  group source/src/packet/src
    ../../../../../../middleware/mcu_bootloader/src/packet/src/: serial_packet.c
  group source/src/property
    ../../../../../../middleware/mcu_bootloader/src/property/: property.h
  group source/src/sbloader
    ../../../../../../middleware/mcu_bootloader/src/sbloader/: sbloader.h sb_file_format.h
  group source/src/sbloader/src
    ../../../../../../middleware/mcu_bootloader/src/sbloader/src/: sbloader.c
  group source/src/utilities
    ../../../../../../middleware/mcu_bootloader/src/utilities/: fsl_rtos_abstraction.h fsl_assert.h vector_table_info.h
  group source/src/utilities/src
    ../../../../../../middleware/mcu_bootloader/src/utilities/src/: fsl_assert.c fsl_rtos_abstraction.c debug_util.c
  group source/src/startup
    ../../../../../../middleware/mcu_bootloader/src/startup/: startup.c
  group usb/device
    ../../../../../../middleware/usb/device/: usb_device_ehci.c usb_device_ehci.h usb_device.h usb_device_dci.c usb_device_dci.h usb_device.h usb_device_dci.h usb_device_ch9.c usb_device_ch9.h
  group usb
    ../../../../../../middleware/usb/: ChangeLogKSDK.txt
  group usb/device/class
    ../../../../../../middleware/usb/device/class/: usb_device_class.c usb_device_class.h usb_device_hid.c usb_device_hid.h
  group source/src/bm_usb
    ../../../../../../middleware/mcu_bootloader/src/bm_usb/: bootloader_hid_report_ids.h fat_directory_entry.h composite.h composite.c hid_bootloader.h hid_bootloader.c usb_descriptor.h usb_descriptor.c
  group source/src/drivers/ocotp
    ../../../../../../middleware/mcu_bootloader/src/drivers/ocotp/: bl_ocotp.c bl_ocotp.h
  group source/src/drivers/serial_nor_eeprom
    ../../../../../../middleware/mcu_bootloader/src/drivers/serial_nor_eeprom/: serial_nor_eeprom.c serial_nor_eeprom.h
  group source/src/drivers/usdhc
    ../../../../../../middleware/mcu_bootloader/src/drivers/usdhc/: bl_usdhc.c bl_usdhc.h
  group source/src/drivers/sdmmc/src
    ../../../../../../middleware/mcu_bootloader/src/drivers/sdmmc/src/: fsl_mmc.c fsl_sd.c fsl_sdmmc_common.c
  group source/src/drivers/sdmmc/inc
    ../../../../../../middleware/mcu_bootloader/src/drivers/sdmmc/inc/: fsl_mmc.h fsl_sd.h fsl_sdmmc_common.h fsl_sdmmc_host.h fsl_sdmmc_spec.h
  group source/src/drivers/sdmmc/port/usdhc/polling
    ../../../../../../middleware/mcu_bootloader/src/drivers/sdmmc/port/usdhc/polling/: fsl_sdmmc_host.c
  group source/src/drivers/semc
    ../../../../../../middleware/mcu_bootloader/src/drivers/semc/: bl_semc.c bl_semc.h bl_semc.c bl_semc.h
  group source/src/drivers/semc_nand
    ../../../../../../middleware/mcu_bootloader/src/drivers/semc_nand/: semc_nand_flash.c semc_nand_flash.h
  group source/src/drivers/nand_ecc
    ../../../../../../middleware/mcu_bootloader/src/drivers/nand_ecc/: nand_ecc.c nand_ecc.h nand_ecc.c nand_ecc.h
  group source/src/drivers/flexspi
    ../../../../../../middleware/mcu_bootloader/src/drivers/flexspi/: bl_flexspi.c bl_flexspi.h bl_flexspi.c bl_flexspi.h
  group source/src/drivers/flexspi_nor
    ../../../../../../middleware/mcu_bootloader/src/drivers/flexspi_nor/: flexspi_nor_flash.c flexspi_nor_flash.h
  group source/src/drivers/flexspi_nand
    ../../../../../../middleware/mcu_bootloader/src/drivers/flexspi_nand/: flexspi_nand_flash.c flexspi_nand_flash.h
  group source/src/drivers/microseconds
    ../../../../../../middleware/mcu_bootloader/src/drivers/microseconds/: microseconds.h
  group source/src/drivers/microseconds/src
    ../../../../../../middleware/mcu_bootloader/src/drivers/microseconds/src/: microseconds_pit.c
  group mcu_bootloader
    ../../../../../../devices/RT/RT1170/MIMXRT1176/: system_MIMXRT1176_cm7.h
  group mcu_bootloader/targets/MIMXRT1176/src/startup
    ../../../../../../middleware/mcu_bootloader/targets/MIMXRT1176/src/startup/: system_MIMXRT1176_cm7.c
  group mcu_bootloader/targets/MIMXRT1176/src/startup/arm
    ../../../../../../middleware/mcu_bootloader/targets/MIMXRT1176/src/startup/arm/: startup_MIMXRT1176_cm7.S
  group source/targets/MIMXRT1176/src
    ../../../../../../middleware/mcu_bootloader/targets/MIMXRT1176/src/: bl_lpuart_irq_config_MIMXRT1176.c bl_mpu.h bootloader_config.h clock_cfg_MIMXRT1176.c external_memory_property_map_MIMXRT1176.c flexspi_config_MIMXRT1176.c flexspi_nand_config_MIMXRT1176.c flexspi_nor_config_MIMXRT1176.c fusemap.h hardware_init_MIMXRT1176.c memory_config.h memory_map_MIMXRT1176.c ocotp_MIMXRT1176.c periph_MIMXRT1176.c peripherals_pinmux.h sdmmc_config_MIMXRT1176.c sdmmc_convert_MIMXRT1176.c sdmmc_init.h security_config_MIMXRT1176.c semc_nand_config_MIMXRT1176.c target_config.h usb_device_config.h sram_init_MIMXRT1176.c
  group source/targets/common/src
    ../../../../../../middleware/mcu_bootloader/targets/common/src/: pinmux_utility_imxrt_series.c
  group source/src/property/src
    ../../../../../../middleware/mcu_bootloader/src/property/src/: property_imx.c
  group source/src/security/keyblob/src
    ../../../../../../middleware/mcu_bootloader/src/security/keyblob/src/: keyblob_caam.c keyblob.c
  group source/src/security/keyblob
    ../../../../../../middleware/mcu_bootloader/src/security/keyblob/: keyblob.h
  group source/src/authentication
    ../../../../../../middleware/mcu_bootloader/src/authentication/: key_store_puf.c key_store_puf.h
